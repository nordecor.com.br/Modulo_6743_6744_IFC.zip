Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-04-17T08:27:34
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Apr 17 08:27:34 2025 * Host: MichellyManno * Database: C:\Users\MICHEL~1\AppData\Local\Temp\3d4ce4e2-a071-4c3a-9fd9-d44fc958818e\96a1e7b4-4b5a-4141-bacf-69b6868c86b9\ifc * Database version: 5507 * Database creation date: Thu Apr 17 08:27:33 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Apr 17 08:27:34 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Apr 17 08:27:34 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcFlowTerminal: 6744, Módulo_SKALY_6743_6744_Nordecor_IFC:6744:328236
In: Nível 1
Type - Material: Metal - Alumínio - Preto, Plástico - PC - Transparente
Type - Cotas - Comprimento conector: 348 mm; Comprimento difusor: 228 mm
Type - Dados - Data de atualização: 17/04/2025; Versão: 1
Type - Dados de identidade - Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: comercial@nordecor.com.br; Descrição: Módulo LED acabamento preto para trilho SKALY FIN dupla seção 6W 2700K 120º; Desenvolvedor: Check BIM; Fabricante: Nordecor; Garantia: 2 anos; IP: 20; Localização: Camboriú/SC - Brasil; Modelo: 6744; Nome do tipo: 6744; Número OmniClass: 23.80.70.11.14.21; Tipo de imagem: Imagem raster: 6744.png; Título OmniClass: Spots and Tracklight Specialties; URL: https://nordecor.com.br/; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/modulo-led-para-trilho-skaly-6w-2-700k/
Type - Elétrico - Comentários de voltagem: DC48V - 2 Seções; Lâmpada: LED
Type - Fotométricos - Ângulo de abertura: 120 deg; Fluxo luminoso: 392 lm; IRC: 97; Potência: 6 W; Temperatura de cor: 2700 K
Type - Gráficos - Simbologia: Imagem raster: 6744 2D.png
Type - Materiais e acabamentos - Difusor: Plástico - PC - Transparente; Spot: Metal - Alumínio - Preto
Type - Outros - Categoria: Luminárias; Branco: no; Nome da família: Módulo_SKALY_6743_6744_Nordecor_IFC; Preto: yes
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 2D: yes; Fonte luminosa: yes
Cotas - Área: 0.00959396 m2; Volume: 0.0000339552 m3
Dados de identidade - Marca: 1
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Família: Módulo_SKALY_6743_6744_Nordecor_IFC: 6744; Família e tipo: Módulo_SKALY_6743_6744_Nordecor_IFC: 6744; ID de tipo: Módulo_SKALY_6743_6744_Nordecor_IFC: 6744; Tipo: Módulo_SKALY_6743_6744_Nordecor_IFC: 6744
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
